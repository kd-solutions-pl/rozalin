require recipes-bsp/firmware-imx/firmware-ele-imx.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=bc649096ad3928ec06a8713b8d787eac"
LICENSE_FLAGS = "NXP_EULA_v63"
LICENSE_FLAGS_DETAILS[NXP_EULA_v63] = "For further details, see ${THISDIR}/files/NXP_EULA_v63"

IMX_SRCREV_ABBREV = "29313e0"
SRC_URI[sha256sum] = "3af1a5e1336ae3379cf573ccdf34fd8adec99005c4abb70ea0f14af3ac5fb1ae"
