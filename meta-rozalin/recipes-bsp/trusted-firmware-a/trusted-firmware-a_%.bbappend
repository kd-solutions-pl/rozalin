TFA_PLATFORM:imx93frdm = "imx93"
TFA_BUILD_TARGET:imx93frdm = "bl31"

COMPATIBLE_MACHINE:imx93frdm = "^imx93frdm$"
