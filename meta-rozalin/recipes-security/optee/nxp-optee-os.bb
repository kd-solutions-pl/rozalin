require nxp-optee-os.inc

PROVIDES += "optee-os"

DEPENDS += "dtc-native"
